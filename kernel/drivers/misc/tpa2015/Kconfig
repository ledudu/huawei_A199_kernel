## kernel/drivers/misc/tpa2015/Kconfig
```kconfig
config TPA2015
    tristate "TPA2015 Driver"
	default y
	help
		Say Y to enable TPA2015 PA Support
```
